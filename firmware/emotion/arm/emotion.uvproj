# Keil uVision project emotion.uvproj, settings and files
target nrf51422_xxaa_s310 (256K) (ARM-ADS)
  device: nRF51422_xxAA Nordic Semiconductor
  cpu: IRAM(0x20002800-0x20003FFF) IROM(0x20000-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: emotion +hex
  c flags: Optim=1 wLevel=2
  c define: NRF51,DEBUG_NRF_USER,BLE_STACK_SUPPORT_REQD,ANT_STACK_SUPPORT_REQD,LOOPBACK
  c misc: --c99
  c include: ..;..\..\nrf51_sdk\Include;..\..\nrf51_sdk\Include\app_common;..\..\nrf51_sdk\Include\ble;..\..\nrf51_sdk\Include\ble\ble_services;..\..\nrf51_sdk\Include\s310;..\..\nrf51_sdk\Include\sd_common;..\services;..\libraries
  memory RVCT4: ROM 0x00020000 size 0x0001F000
  memory RVCT9: RAM 0x20002400 size 0x00001C00
  group Startup Code
    ./../../nrf51_sdk/Source/templates/arm/: arm_startup_nrf51422_s310.s
    ./../../nrf51_sdk/Source/templates/: system_nrf51.c
  group Source Code
    ./../: main.c
    ../: ble_ant.c ble_ant_stack_handler.c irt_peripheral.c
    ../libraries/: power.c resistance.c speed.c
  group Services
    ../../nrf51_sdk/Source/ble/ble_services/: ble_dis.c ble_bas.c ble_hrs.c
    ../services/: ble_nus.c ble_cps.c ant_bike_power.c
  group Libraries
    ../libraries/: nrf_pwm.c
    ../../nrf51_sdk/Source/ble/: ble_error_log.c ble_advdata.c ble_conn_params.c ble_bondmngr.c ble_flash.c ble_radio_notification.c ble_debug_assert_handler.c
    ../../nrf51_sdk/Source/ble/ble_services/: ble_srv_common.c
    ../../nrf51_sdk/Source/app_common/: app_timer.c app_button.c app_gpiote.c
