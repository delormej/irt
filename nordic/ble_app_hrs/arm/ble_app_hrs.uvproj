# Keil uVision project ble_app_hrs.uvproj, settings and files
target nrf51822_xxaa_s110 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ble_app_hrs +hex
  c flags: Optim=4 oTime=1 wLevel=2
  c define: NRF51 DEBUG_NRF_USER BOARD_PCA10001
  c misc: --c99
  c include: ..;..\..\nrf51822\Include;..\..\nrf51822\Include\app_common;..\..\nrf51822\Include\ble;..\..\nrf51822\Include\ble\ble_services;..\..\nrf51822\Include\ble\softdevice;..\..\emotion
  memory RVCT4: ROM 0x14000 size 0x2b000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group Startup Code
    ../../nrf51822/Source/templates/arm/: arm_startup_nrf51.s
    ../../nrf51822/Source/templates/: system_nrf51.c
  group Source Code
    ./../: main.c
    ../: battery.c led.c
  group Services
    ../../nrf51822/Source/ble/ble_services/: ble_dis.c ble_bas.c ble_hrs.c
    ../../emotion/: ble_cps.c
  group Libraries
    ../../nrf51822/Source/ble/: ble_conn_params.c ble_advdata.c ble_stack_handler.c ble_bondmngr.c ble_flash.c ble_radio_notification.c ble_error_log.c ble_debug_assert_handler.c
    ../../nrf51822/Source/ble/ble_services/: ble_srv_common.c
    ../../nrf51822/Source/app_common/: app_timer.c app_button.c app_gpiote.c
    ../../nrf51822/Source/nrf_delay/: nrf_delay.c
    ../../emotion/: nrf_pwm.c resistance.c revolutions.c
target nrf51822_xxab_s110 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic
  cpu: as above
  output: ble_app_hrs +hex
  c flags: Optim=4 oTime=1 wLevel=2
  c define: NRF51 DEBUG_NRF_USER
  c misc: --c99
  c include: ..;..\..\..\..\..\Include;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\ble\softdevice
  memory RVCT4: ROM 0x14000 size 0xb000
  memory RVCT9: RAM 0x20002000 size 0x2000
