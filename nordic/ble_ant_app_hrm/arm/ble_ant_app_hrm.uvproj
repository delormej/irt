# Keil uVision project ble_ant_app_hrm.uvproj, settings and files
target nrf51922_xxaa_s310 (256K) (ARM-ADS)
  device: nRF51922_xxAA Nordic
  cpu: IRAM(0x20002800-0x20003FFF) IROM(0x20000-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ble_ant_app_hrm +hex
  c flags: Optim=1 wLevel=2
  c define: NRF51,DEBUG_NRF_USER,BOARD_NRF6310,LOOPBACK
  c misc: --c99
  c include: ..;..\..\nrf51922\Include;..\..\nrf51922\Include\app_common;..\..\nrf51922\Include\ble;..\..\nrf51922\Include\ble\ble_services;..\..\nrf51922\Include\ant_ds\softdevice;..\..\emotion;..\..\ble_app_hrs;..\..\ble_app_uart
  memory RVCT4: ROM 0x20000 size 0x1f000
  memory RVCT9: RAM 0x20002800 size 0x1800
  group Startup Code
    ./../: arm_startup_nrf51.s
    ../../nrf51922/Source/templates/: system_nrf51.c
  group Source Code
    ../../ble_app_hrs/: main.c led.c battery.c
    ../../emotion/: resistance.c speed.c power.c
  group Services
    ../../nrf51822/Source/ble/ble_services/: ble_dis.c ble_bas.c
    ../../emotion/: ble_cps.c
    ../../ble_app_uart/: ble_nus.c
    ../../nrf51922/Source/ble/ble_services/: ble_hrs.c
  group Libraries
    ../../nrf51822/Source/ble/: ble_conn_params.c ble_advdata.c ble_stack_handler.c ble_flash.c ble_radio_notification.c ble_error_log.c ble_debug_assert_handler.c
    ../../nrf51822/Source/ble/ble_services/: ble_srv_common.c
    ../../nrf51822/Source/app_common/: app_timer.c app_button.c app_gpiote.c
    ../../nrf51822/Source/nrf_delay/: nrf_delay.c
    ../../emotion/: nrf_pwm.c
    ../../nrf51922/Source/ble/: ble_conn_params.c ble_bondmngr.c ble_flash.c ble_radio_notification.c ble_debug_assert_handler.c
    ../../nrf51922/Source/simple_uart/: simple_uart.c
